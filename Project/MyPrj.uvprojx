# Keil uVision project MyPrj.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyPrj +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FMLIB\inc;..\User;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c FreeRTOSConfig.h stm32f10x_conf.h stm32f10x_it.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FMLIB
    ../Libraries/FMLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group FreeRTOS
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM3/: port.c
